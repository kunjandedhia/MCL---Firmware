# Keil uVision project Project.uvprojx, settings and files
target STM32F429 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SCU_V4_1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  c include: ..\MCL_SCU_Include;..\ST_Libraries\CMSIS\Include;..\ST_Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\ST_Libraries\STM32F4xx_StdPeriph_Driver\inc;..\ST_Libraries\STM32F4xx_ETH_Driver\inc;..\Ethernet_Stack\lwip-1.4.1\src\include;..\Ethernet_Stack\lwip-1.4.1\src\include\lwip;..\Ethernet_Stack\lwip-1.4.1\src\include\netif;..\Ethernet_Stack\lwip-1.4.1\src\include\ipv4;..\Ethernet_Stack\lwip-1.4.1\port\STM32F4xx;..\Ethernet_Stack\lwip-1.4.1\port\STM32F4xx\Standalone
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../ST_Libraries/CMSIS/Device/ST/STM32F4xx/Source/: system_stm32f4xx.c
  group MDK-ARM
    ../ST_Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group SCU_APP
    ../MCL_SCU_Source/: USART.c EEPROM.c I2C.c Miscellaneous.c SCUCan.c PressureRegulator.c RTC.c System_Init.c Timer.c Main.c stm32f4xx_it.c Data_Logging.c Wifi.c xml.c serial_debug.c Netconfig.c ETH_Config.c Ethernet_Server.c UserFlash.c
  group LwIP
    ../Ethernet_Stack/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Ethernet_Stack/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../Ethernet_Stack/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../Ethernet_Stack/lwip-1.4.1/src/netif/: etharp.c
    ../Ethernet_Stack/lwip-1.4.1/port/STM32F4xx/Standalone/: ethernetif.c
  group STM32F4xx_StdPeriph_Driver
    ../ST_Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_rtc.c stm32f4xx_can.c stm32f4xx_dac.c stm32f4xx_i2c.c stm32f4xx_pwr.c
  group STM32F4xx_ETH_Driver
    ../ST_Libraries/STM32F4xx_ETH_Driver/src/: stm32f4xx_eth.c
