# Keil uVision project HMIpjt.uvprojx, settings and files
target HMI (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HMI_V2_6 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,
  c include: .\Libraries\CMSIS\Device\ST\STM32F10x\Include;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\OP_Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS_Core
    ./CMSIS_Core/: cmsis_armcc.h core_cm3.h core_cmFunc.h core_cmInstr.h
  group CMSIS
    ./Libraries/CMSIS/Device/ST/STM32F10x/Source/: system_stm32f10x.c
    ./: startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_rcc.c stm32f10x_tim.c
  group HMI_APP
    ./OP_Source/: Can_Func.c Debug.c I2C_Func.c Interrupt_Han.c Lcd_Func.c Main.c Miscellaneous.c Sw_Func.c SystemInit.c Timer.c Uart.c Font_Franklin24.c Font_Franklin20.c Time_Conversion.c
