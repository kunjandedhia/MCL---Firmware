# Keil uVision project VCMpjt.uvprojx, settings and files
target VCM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VCM_V2_3 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Libraries\CMSIS\Device\ST\STM32F10x\Include;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\VCM_Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./Libraries/CMSIS/Device/ST/STM32F10x/Source/: system_stm32f10x.c
    ./: startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_i2c.c
  group CMSIS_Core
    ./CMSIS_Core/: cmsis_armcc.h core_cm3.h core_cmFunc.h core_cmInstr.h
  group VCM_APP
    ./VCM_Source/: Main.c System_Init.c Timer.c Uart.c Adc.c I2C.c CAN.c CAN_Parser.c Stall_Test.c Misc_Functions.c Solenoid_Valve.c Pressure_Sensors.c Linear_Transducer.c Interrupt_Han.c Debug.c
